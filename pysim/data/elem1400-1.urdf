Commit message: add save

File: pysim/data/elem1400-1.urdf (robot description, URDF)
Before this commit: robot ele1400, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=1.3 0.05 0.2; visual box size=1.3 0.05 0.2
